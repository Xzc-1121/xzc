# Keil uVision project SmartHomeSensing.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: SmartHomeSensing +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source Group 1
    ./src/: delay.c main.c delay.h uart.c uart.h dht11.c dht11.h esp8266.c esp8266.h bh1750.c bh1750.h sr505.c sr505.h
